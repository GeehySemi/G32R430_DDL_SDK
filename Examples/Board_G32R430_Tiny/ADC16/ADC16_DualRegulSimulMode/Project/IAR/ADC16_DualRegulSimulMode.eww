<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC16_DualRegulSimulMode.ewp</path>
    </project>
    <batchBuild />
</workspace>
