<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC16_ContinuousConversion.ewp</path>
    </project>
    <batchBuild />
</workspace>
