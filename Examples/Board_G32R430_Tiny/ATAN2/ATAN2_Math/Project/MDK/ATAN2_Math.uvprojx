# Keil uVision project ATAN2_Math.uvprojx, settings and files
target G32R430_FLASH (6240000::V6.24::ARMCLANG)
  device: G32R430CB Geehy
  pack: Geehy.G32R4xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00004000) IRAM2(0x00000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M52") DSP CDECP(0x08) PACBTI CLOCK(12000000) ELITTLE
  output: ATAN2_Math
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: G32R430,G32R430_TINY,USE_FULL_DDL_DRIVER,VECT_TAB_SRAM
  c misc: -mcpu=cortex-m52+nomve+nofp+cdecp3
  c include: ..\..\..\..\..\..\Libraries\G32R4xx_DDL_Driver\Include;..\..\..\..\..\..\Libraries\CMSIS\Core\Include;..\..\..\..\..\..\Libraries\Device\Geehy\G32R4xx\Include;..\..\..\..\..\..\Libraries\ATAN2;..\..\Include;..\..\..\..\..\..\Boards
  asm misc: -mcpu=cortex-m52+nomve+nofp+cdecp3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x0 size 0x8000
  scatter file: ..\..\..\..\..\..\Libraries\Device\Geehy\G32R4xx\Source\arm\g32r430xb_flash.sct
  group Application
    ../../Source/: main.c g32r4xx_int.c
  group Board
    ../../../../../../Boards/: board.c
  group DDL_Driver
    ../../../../../../Libraries/G32R4xx_DDL_Driver/Source/: g32r4xx_ddl_adc12.c g32r4xx_ddl_adc16.c g32r4xx_ddl_comp.c g32r4xx_ddl_dac.c g32r4xx_ddl_dbgmcu.c g32r4xx_ddl_dma.c g32r4xx_ddl_eint.c g32r4xx_ddl_flash.c g32r4xx_ddl_gpio.c g32r4xx_ddl_i2c.c g32r4xx_ddl_lptmr.c g32r4xx_ddl_nvic.c g32r4xx_ddl_pmu.c g32r4xx_ddl_rcm.c g32r4xx_ddl_rtc.c g32r4xx_ddl_spi.c g32r4xx_ddl_tmr.c g32r4xx_ddl_usart.c
  group Document
    ../../: readme.txt
  group CMSIS
    ../../Source/: system_g32r4xx.c
    ../../../../../../Libraries/Device/Geehy/G32R4xx/Source/: startup_g32r430xx.c
  group g32r430_ATAN2
    ../../../../../../Libraries/ATAN2/: g32r430_ATAN2_high_resolution_AC6.lib
target G32R430_RAM (6240000::V6.24::ARMCLANG)
  device: G32R430CB Geehy
  pack: Geehy.G32R4xx_DFP.1.0.4
  cpu: as above
  output: ATAN2_Math_ITCM_RAM
  c flags: as above
  c define: G32R430,G32R430_TINY,USE_FULL_DDL_DRIVER,VECT_TAB_SRAM
  c misc: -mcpu=cortex-m52+nomve+nofp+cdecp3
  c include: as above
  asm misc: -mcpu=cortex-m52+nomve+nofp+cdecp3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x0 size 0x8000
  scatter file: .\g32r430xb_itcm_ram.sct
