<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ATAN2_Math.ewp</path>
    </project>
    <batchBuild />
</workspace>
