# IAR project ATAN2_Math.ewp, settings and files
configuration G32R430_FLASH (ARM, debug)
  General.OGChipSelectEditMenu: G32R430xB Geehy G32R430xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 0
  ICCARM.CCDefines: G32R430; G32R430_TINY; USE_FULL_DDL_DRIVER; VECT_TAB_SRAM
  ICCARM.IExtraOptions: --cdecp=3
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\..\Libraries\ATAN2; ..\..\..\..\..\..\Libraries\Device\Geehy\G32R4xx\Include; ..\..\..\..\..\..\Libraries\G32R4xx_DDL_Driver\Include; ..\..\..\..\..\..\Libraries\CMSIS\Core\Include; ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\ATAN2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: --cdecp=3
  OBJCOPY.OOCOutputFile: ATAN2_Math.hex
  ILINK.IlinkOutputFile: ATAN2_Math.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration G32R430_RAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: g32r430xb_itcm_ram.icf
  group Application
    ../../Source/: g32r4xx_int.c main.c
  group Board
    ../../../../../../Boards/: board.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/G32R4xx/Source/: startup_g32r430xx.c
    ../../Source/: system_g32r4xx.c
  group g32r430_ATAN2
    ../../../../../../Libraries/ATAN2/: g32r430_ATAN2_high_resolution_ICC.a
  group DDL_Driver
    ../../../../../../Libraries/G32R4xx_DDL_Driver/Source/: g32r4xx_ddl_adc12.c g32r4xx_ddl_adc16.c g32r4xx_ddl_comp.c g32r4xx_ddl_dac.c g32r4xx_ddl_dbgmcu.c g32r4xx_ddl_dma.c g32r4xx_ddl_eint.c g32r4xx_ddl_flash.c g32r4xx_ddl_gpio.c g32r4xx_ddl_i2c.c g32r4xx_ddl_lptmr.c g32r4xx_ddl_nvic.c g32r4xx_ddl_pmu.c g32r4xx_ddl_rcm.c g32r4xx_ddl_rtc.c g32r4xx_ddl_spi.c g32r4xx_ddl_tmr.c g32r4xx_ddl_usart.c
